# IAR project gpio_key_light.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103C8 ST STM32F103C8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_MD
  ICCARM.CCIncludePath2: ; ..\..\; ..\..\User; ..\..\User\hard; ..\..\User\mcu_sdk; ..\..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x; ..\..\Libraries\STM32F10x_StdPeriph_Driver\inc; ..\..\src; ..\..\examples\smart_switch_demo
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: gpio_key_light.bin
  ILINK.IlinkOutputFile: gpio_key_light.out
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\CONFIG\generic_cortex.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group CMSIS
    ../../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/iar/: startup_stm32f10x_md.s
    ../../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group handle
    ../../examples/smart_switch_demo/: data_handle.c data_handle.h gpio_key.c gpio_key.h gpio_light.c gpio_light.h include.h main.c
  group Libraries
    ../../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c
  group user
    ../../src/: stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h user_timer.c user_timer.h user_uart.c user_uart.h
