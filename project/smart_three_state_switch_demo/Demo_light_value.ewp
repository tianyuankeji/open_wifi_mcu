# IAR project Demo_light_value.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_MD
  ICCARM.CCIncludePath2: ; ..\..\; ..\..\User; ..\..\User\hard; ..\..\User\mcu_sdk; ..\..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x; ..\..\Libraries\STM32F10x_StdPeriph_Driver\inc; ..\..\src; ..\..\examples\smart_three_state_switch_demo
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Demo_light_value.bin
  ILINK.IlinkOutputFile: Demo_light_value.out
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group CMSIS
    ../../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/iar/: startup_stm32f10x_md.s
    ../../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group Hand
    ../../examples/smart_three_state_switch_demo/: data_handle.c data_handle.h gpio_key.c gpio_key.h gpio_light.c gpio_light.h include.h main.c
  group Librarise
    ../../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c
  group User
    ../../src/: stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h user_timer.c user_timer.h user_uart.c user_uart.h
    ../../Libraries/STM32F10x_StdPeriph_Driver/src/: stm32f10x_gpio.c
